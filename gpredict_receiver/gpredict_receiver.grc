options:
  parameters:
    author: Burkhardt, Tinker
    generate_options: qt_gui
    id: gpredict_receiver
    output_language: python
    title: gpredict_receiver
  states: {}

blocks:
- name: bandwidth_rec
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: corrected_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: correction_mode
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 4,0
    initPressed: 'False'
    label: GPredict Enable
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0
    label: Carrier Frequency
    type: real
    value: 850e6
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0
    label: RX Gain
    type: real
    value: '20'
  states: {}
- name: lowpass_custom_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: taps_cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: taps_trans
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0
    label: Sample Rate
    type: real
    value: 300e3
  states: {}
- name: taps_cutoff
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: 1e3
    stop: 50e6
    value: 300e3
  states: {state: disabled}
- name: taps_trans
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: 1e3
    stop: 5e6
    value: 300e3
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: corrected_freq
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: corrected_freq
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_custom_taps
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: corrected_freq
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_custom_taps
  states: {state: disabled}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1
    name: '"not-corrected"'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1
    name: '"corrected"'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 5,0
    name: '"rx_not-corrected"'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: corrected_freq
    fftsize: '1024'
    gui_hint: 6,0
    name: '"rx_corrected"'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: bandwidth_rec
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [soapy_limesdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0_1_1, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0_1_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
