options:
  parameters:
    author: Burkhardt, Tinker
    generate_options: qt_gui
    id: gpredict_receiver
    output_language: python
    thread_safe_setters: '1'
    title: gpredict_receiver
  states: {}

blocks:
- name: bandwidth_rec
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: corrected_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0
    label: Carrier Frequency - Corrected
    type: real
    value: 850e6
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0
    label: Carrier Frequency
    type: real
    value: 850e6
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0
    label: RX Gain
    type: real
    value: '20'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0
    label: Sample Rate
    type: real
    value: 200e3
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 14e3
    sample_rate: samp_rate
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: corrected_freq
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: corrected_freq
    fftsize: '1024'
    gui_hint: 6,0
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: bandwidth_rec
    center_freq: corrected_freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_freqshift_cc_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_freqshift_cc_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_0, inpair]
- [soapy_limesdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
