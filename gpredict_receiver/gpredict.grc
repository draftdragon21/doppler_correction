options:
  parameters:
    generate_options: qt_gui
    id: basic_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth_rec
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 50e6
    value: 10e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 850e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: lowpass_custom_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: taps_cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: taps_trans
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: taps_cutoff
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 30e6
    value: 10e6
  states: {}
- name: taps_trans
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 20e6
    value: 10e6
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_custom_taps
  states: {state: disabled}
- name: qtgui_sink_x_0_0_1_0_1_1
  id: qtgui_sink_x
  parameters:
    bw: 20e6
    fc: '0'
    fftsize: '1024'
    name: XLATING_Receiver
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    rate: '500'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_1_0_1_1_0
  id: qtgui_sink_x
  parameters:
    bw: 20e6
    fc: freq
    fftsize: '1024'
    name: Raw_Receiver
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    rate: '500'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: bandwidth_rec
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_sink_x_0_0_1_0_1_1, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_sink_x_0_0_1_0_1_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
