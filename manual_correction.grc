options:
  parameters:
    author: Burkhardt & Tinker
    generate_options: qt_gui
    id: fm_sdr_test
    output_language: python
    title: fm_sdr_test
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 87.5e6
    step: 0.1e6
    stop: 108e6
    value: 91.3e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 576e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: volume
    type: float
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '3'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 144e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '3'
    quad_rate: 144e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '50000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 200e3
    fc: freq
    fftsize: '1024'
    rate: '100'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '75000'
    fc: '0'
    fftsize: '1024'
    rate: '100'
    showrf: 'True'
    type: float
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: 300e3
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_fm_demod_cf_0, '0', blocks_multiply_xx_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
